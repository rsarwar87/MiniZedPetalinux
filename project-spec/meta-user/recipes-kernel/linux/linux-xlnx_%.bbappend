SRC_URI += "file://user_2017-05-17-14-19-00.cfg \
            file://user_2017-06-25-16-27-00.cfg \
            file://user_2017-06-26-21-37-00.cfg \
            file://user_2018-02-22-14-16-00.cfg \
            file://user_2020-06-09-10-46-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

